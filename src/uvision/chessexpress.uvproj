# Keil uVision project chessexpress.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1114/102 NXP
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: chessexpress
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Startup
    ./: startup_LPC11xx.s system_LPC11xx.c
  group Serial
    ../serial/: Retarget.c Serial.c interface.c
  group MCU
    ../mcu/: mcu.c
  group Chess
    ../chess/: board.c
  group Main
    ../: main.c
  group Utils
    ../: lpc_utils.c
  group Game
    ../game/: game.c
